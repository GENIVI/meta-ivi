base_bindir = "/usr/bin"
base_sbindir = "/usr/sbin"
base_libdir = "/usr/lib"
