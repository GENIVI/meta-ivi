DEPENDS = "virtual/libx11 alsa-lib freetype liboil libogg libvorbis libxv libtheora util-linux tremor gstreamer"
