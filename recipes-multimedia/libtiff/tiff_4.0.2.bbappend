DEPENDS = "zlib jpeg lzo"
