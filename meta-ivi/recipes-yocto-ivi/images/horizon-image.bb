# Base this image on generic IVI image
include recipes-yocto-ivi/images/ivi-image.bb

PV = "6.0.2"

