# Base this image on generic IVI image
require recipes-yocto-ivi/images/ivi-image.bb

PV = "12.0.0"

