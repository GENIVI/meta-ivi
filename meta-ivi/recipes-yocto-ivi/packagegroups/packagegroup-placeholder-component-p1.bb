DESCRIPTION = "GENIVI P1 Placeholder components (PC)"
LICENSE = "MIT"
PR = "r0"

inherit packagegroup

PACKAGES = "\
    packagegroup-placeholder-component-p1 \
"

ALLOW_EMPTY_${PN} = "1"
