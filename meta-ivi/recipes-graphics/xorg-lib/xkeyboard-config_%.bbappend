# FIX ME
# Temporary fix until patch is merged in yocto:
# http://lists.openembedded.org/pipermail/openembedded-core/2014-November/098774.html
inherit gettext
