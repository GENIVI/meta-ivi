PACKAGECONFIG_append = "gallium gallium-egl gallium-llvm"
