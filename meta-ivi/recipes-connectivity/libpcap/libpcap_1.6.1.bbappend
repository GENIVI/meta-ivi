PACKAGECONFIG_remove = "bluetooth"
PACKAGECONFIG[bluetooth] = "--enable-bluetooth, --disable-bluetooth, bluez5"

PR = "r1"