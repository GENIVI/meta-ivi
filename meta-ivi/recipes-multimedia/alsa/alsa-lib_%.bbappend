PR = "r1"

ALLOW_EMPTY_${PN} = "1"
