PACKAGECONFIG[bluez] = "--enable-bluez,--disable-bluez,bluez5"

