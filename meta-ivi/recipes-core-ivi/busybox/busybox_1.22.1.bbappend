FILESEXTRAPATHS_append := ":${THISDIR}/${PN}-${PV}"
SRC_URI += "file://defconfig"
