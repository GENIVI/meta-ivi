#
# for debugging only
#
EXTRA_OECONF_qemux86 = "--enable-developer \
    --enable-verbose-mode \
    --enable-asserts \
    "
