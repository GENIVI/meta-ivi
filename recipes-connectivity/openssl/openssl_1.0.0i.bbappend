base_libdir = "${libdir}"
base_bindir = "${bindir}"
base_sbindir = "${sbindir}"
