DEPENDS_remove = "bluez4"
DEPENDS_append = " bluez5"

PR = "r1"