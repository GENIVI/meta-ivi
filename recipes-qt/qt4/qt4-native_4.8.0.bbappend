DEFAULT_PREFERENCE = "0"
