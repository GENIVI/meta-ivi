PRINC := "${@int(PRINC) + 1}"
PACKAGECONFIG_append_vexpressa9 = " gles egl"
