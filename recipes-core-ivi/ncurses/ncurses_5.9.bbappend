base_libdir = "${libdir}"
base_sbindir = "${sbindir}"
base_bindir = "${bindir}"
