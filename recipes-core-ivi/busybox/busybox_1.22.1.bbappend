FILESEXTRAPATHS := "${THISDIR}/${PN}-${PV}"
SRC_URI += "file://defconfig"
