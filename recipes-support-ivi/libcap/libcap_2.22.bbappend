base_libdir = "${libdir}"
base_prefix = "${prefix}"
