base_libdir = "/usr/lib"
base_bindir = "/usr/bin"
base_sbindir = "/usr/sbin"
